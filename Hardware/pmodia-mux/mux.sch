File: Hardware/pmodia-mux/mux.sch (EAGLE design)
At the start: 17 parts, among them X1 FH12-16S-0.5SH

Commit message: Add files via upload
Parts:
- renumbered X1 to X2
